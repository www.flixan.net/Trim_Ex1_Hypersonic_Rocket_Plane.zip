BATCH MODE INSTRUCTIONS ...............                                                             
Batch for preparing the Rocket-Plane Descent Model
! This batch set creates the analysis models for the Rocket-Plane during Descent.
! (1)- Generates the Flight Vehicle Dynamic Model at T=455 (sec),
! (2)- Generates the Mixing Logic Matrix at the same Flight Condition,
! (3)- Connects the Mixing-Logic Matrix at the Input of the Flight Vehicle,
! (4)- Splits the System in two separate, Pitch and Lateral sub-systems,
! (5)- Generates Pitch and Lateral state-space m-functions for Matlab Analysis
!
Flight Vehicle   : Rocket-Plane Mission-1, Descent Phase/ T= 455.0 sec  
Mixing Matrix    : Mixing Logic Matrix for the Rocket-Plane during Descent
System Connection: Rocket-Plane Mission-1, Descent Phase (Including Mixing Matrix)  
System Modificat : Rocket-Plane Mission-1, Descent Phase (Pitch Model)
System Modificat : Rocket-Plane Mission-1, Descent Phase (Pitch Design Model)
System Modificat : Rocket-Plane Mission-1, Descent Phase (Lateral Model)
System Modificat : Rocket-Plane Mission-1, Descent Phase (Lateral Design Model)
To Matlab Format : Rocket-Plane Mission-1, Descent Phase (Including Mixing Matrix)
To Matlab Format : Rocket-Plane Mission-1, Descent Phase (Pitch Model)
To Matlab Format : Rocket-Plane Mission-1, Descent Phase (Pitch Design Model)
To Matlab Format : Rocket-Plane Mission-1, Descent Phase (Lateral Model)
To Matlab Format : Rocket-Plane Mission-1, Descent Phase (Lateral Design Model)
------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
FLIGHT VEHICLE INPUT DATA ......
Rocket-Plane Mission-1, Descent Phase/ T= 455.0 sec                                                 
! This Flight Vehicle Model is created by the Trim program which combines various types of data     
! files such as: trajectory, mass properties, engine, and basic aero and control surface            
! coefficients data. A Linear State-Space model of the vehicle is created at a selected trajectory  
! flight time. The user may modify the input data or add more options either by editing the input   
! file directly or by means of the window dialogs which are available in the Flight Vehicle         
! Modeling program.                                                                                 
Body Axes Output,Attitude=Euler Angles,No GAFD-Hpar, No Turn Coordination  
 
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :   433.200       32.1740      0.208960E+08
Moments and products of Inertias Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :   9406.72       81388.3       85466.7       0.00000      -617.397       0.00000    
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        :  -31.5596       0.00000       1.24000    
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :  0.650000       560.000       125.0000      44481.0    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         : -0.600000      -3.21700       0.00000      -31.8520    
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :   4.000         0.00000      0.299997E-02   0.00000    
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :   0.00000      -3.80000       0.00000       0.00000      0.220000E-01   0.00000    
W-Gust Azim & Elev angles (deg), or Torque/Force direction (x,y,z), Force Locat (x,y,z)  :   Gust         45.0000      90.0000                                             
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :   390.640       50.0000       30.8090    
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} :  -31.5000       0.00000       0.00000       0.00000    
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:  0.414003E-01  0.267606E-02  0.423335E-04   0.00000       0.00000       0.00000       0.00000    
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:   0.00000     -0.123640E-01   0.00000       0.00000       0.00000       0.00000       0.00000    
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}: -0.436628     -0.631265E-01   0.00000       0.00000       0.00000       0.00000     -0.240835E-03
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:   0.00000     -0.132720E-02   0.00000       0.00000       0.00000       0.00000    
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}: -0.124265E-01 -0.466611E-03   0.00000       0.00000       0.00000     -0.167501E-04   0.00000    
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:   0.00000      0.363200E-02   0.00000       0.00000       0.00000       0.00000    

Number of Control Surfaces, With or No TWD (Tail-Wags-Dog and Hinge Moment Dynamics) ?   :  4   NO TWD  

Control Surface No:  1                                                                     Elevon         
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg):  -3.65040       30.0000      -30.0000       0.00000       0.00000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   10.0000       100.000       2.00000       2.36000       11.8100    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.645000E-02   0.00000     -0.164480E-01 -0.955000E-01
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -41.4000       0.00000       2.00000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.581500E-03   0.00000     -0.189900E-01   0.00000       0.00000       0.00000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:   0.00000     -0.287300E-02   0.00000       0.00000       0.00000       0.00000    
Control Surface No:  2                                                                     Body Flap      
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg):  -0.7860        30.0000      -30.0000       0.00000       0.00000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   10.0000       100.000       2.00000       2.41000       17.2200    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.389500E-03   0.00000     -0.699360E-02  0.465300E-01
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -50.0000       0.00000       0.00000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}: -0.126300E-03   0.00000     -0.216400E-02   0.00000       0.00000       0.00000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:   0.00000     -0.650000E-03   0.00000       0.00000       0.00000       0.00000    
Control Surface No:  3                                                                     Aileron        
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg):   0.00000       25.0000      -25.0000       0.00000       0.00000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   10.0000       100.000       2.00000       2.36000       11.8100    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.645000E-02   0.00000     -0.123400E-01 -0.955000E-01
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -41.4000       0.00000       0.00000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:   0.00000       0.00000       0.00000       0.00000       0.00000       0.00000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.642200E-02   0.00000     -0.366200E-03   0.00000       0.00000       0.00000    
Control Surface No:  4                                                                     Rudder         
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg):   0.00000       30.0000      -30.0000       90.0000       0.00000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   10.0000       100.000       2.00000       2.10000       13.4400    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           :   0.00000       0.00000     -0.754000E-03   0.00000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -48.8000       0.00000      -3.00000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:   0.00000      0.262967E-02   0.00000       0.00000       0.00000       0.00000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.181933E-03   0.00000     -0.127400E-02   0.00000       0.00000       0.00000    

Number of Accelerometers, Along Axis: (x,y,z)                                            :  3
Acceleromet No  1 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  X-axis Accelerat.     -31.5596        0.00000        1.24000    
Acceleromet No  2 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  Y-axis Accelerat.     -31.5596        0.00000        1.24000    
Acceleromet No  3 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  Z-axis Accelerat.     -31.5596        0.00000        1.24000    
                                                                                                    
----------------------------------------------------------------------------------------------------------------------------------------------------------------
MIXING LOGIC MATRIX DATA ..........    (Matrix Title, Name, Vehicle Title, Control Directions)
Mixing Logic Matrix for the Rocket-Plane during Descent                                                                            Title
! Mixing Logic Matrix for the Rocket-Plane during Descent at T=455                                                                 Comments
Kmix_455                                                                                                                           Matrix Name
Rocket-Plane Mission-1, Descent Phase/ T= 455.0 sec                                                                                Vehicle Data
P-dot Roll  Acceleration About X Axis                                                                                              3-rotational dofs
Q-dot Pitch Acceleration About Y Axis                                           
R-dot Yaw   Acceleration About Z Axis                                           
----------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Rocket-Plane Mission-1, Descent Phase (Including Mixing Matrix)
! Vehicle is combined with Mixing Logic Matrix at its Input
Titles of Systems to be Combined
Title 1 Rocket-Plane Mission-1, Descent Phase/ T= 455.0 sec                                                        
SYSTEM INPUTS TO SUBSYSTEM  1                                                                   Inputs from FCS
Via Matrix +Kmix_455
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1                                                                All Outputs
Via Matrix +I14
..............................................................................
Definitions of Inputs  =  3
P-dot Roll  FCS Demand About X Axis                                           
Q-dot Pitch FCS Demand About Y Axis                                           
R-dot Yaw   FCS Demand About Z Axis                                           
 
Definitions of Outputs =  14
Roll Attitude  (phi-123)   (radians)                                                         
Roll Rate      (p-body)    (rad/sec)                                                         
Pitch Attitude (thet-123)  (radians)                                                         
Pitch Rate     (q-body)    (rad/sec)                                                         
Yaw  Attitude  (psi-123)   (radians)                                                         
Yaw  Rate      (r-body)    (rad/sec)                                                         
Angle of attack, alfa, (radians)                                                             
Angle of sideslip, beta, (radian)                                                            
Change in Altitude, delta-h, (feet)                                                          
Forward Acceleration  (V-dot)  (ft/sec)                                                      
Cross Range Velocity (Vcr) (ft/sec)                                                          
Accelerom #  1, (along X), (ft/sec^2) Translat. Accelerat.                                   
Accelerom #  2, (along Y), (ft/sec^2) Translat. Accelerat.                                   
Accelerom #  3, (along Z), (ft/sec^2) Translat. Accelerat.                                   
------------------------------------------------------------------------------------------------------------------------------
CREATE A NEW SYSTEM FROM AN OLD SYSTEM... (Titles of the New and Old Systems)
Rocket-Plane Mission-1, Descent Phase (Pitch Model)
Rocket-Plane Mission-1, Descent Phase (Including Mixing Matrix)                       
! The pitch system is extracted from the coupled system above                                     
TRUNCATE OR REORDER THE SYSTEM INPUTS, STATES, AND OUTPUTS
Extract Inputs :   2   
Extract States :   3   4   7   9  10
Extract Outputs:   3   4   7   9  10  14
-------------------------------------------------------------------------------------------------------------------------------
CREATE A NEW SYSTEM FROM AN OLD SYSTEM... (Titles of the New and Old Systems)
Rocket-Plane Mission-1, Descent Phase (Pitch Design Model)
Rocket-Plane Mission-1, Descent Phase (Including Mixing Matrix)                       
! The pitch system is extracted from the coupled system above                                     
TRUNCATE OR REORDER THE SYSTEM INPUTS, STATES, AND OUTPUTS
Extract Inputs :   2   
Extract States :   4   7   
Extract Outputs:   4   7   
-------------------------------------------------------------------------------------------------------------------------------
CREATE A NEW SYSTEM FROM AN OLD SYSTEM... (Titles of the New and Old Systems)
Rocket-Plane Mission-1, Descent Phase (Lateral Model)
Rocket-Plane Mission-1, Descent Phase (Including Mixing Matrix)                       
! The pitch system is extracted from the coupled system above                                     
TRUNCATE OR REORDER THE SYSTEM INPUTS, STATES, AND OUTPUTS
Extract Inputs :   1   3
Extract States :   1   2   5   6   8  
Extract Outputs:   1   2   5   6   8   11  13
-----------------------------------------------------------------------------------------------------------------------------------------------------
CREATE A NEW SYSTEM FROM AN OLD SYSTEM... (Titles of the New and Old Systems)
Rocket-Plane Mission-1, Descent Phase (Lateral Design Model)
Rocket-Plane Mission-1, Descent Phase (Including Mixing Matrix)                       
! The pitch system is extracted from the coupled system above                                     
TRUNCATE OR REORDER THE SYSTEM INPUTS, STATES, AND OUTPUTS
Extract Inputs :   1   3
Extract States :   1   2   6   8  
Extract Outputs:   1   2   6   8  
-----------------------------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Rocket-Plane Mission-1, Descent Phase (Including Mixing Matrix)
System
vehicle_mix.m
------------------------------------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Rocket-Plane Mission-1, Descent Phase (Pitch Model)
System
pitch_455.m
------------------------------------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Rocket-Plane Mission-1, Descent Phase (Lateral Model)
System
later_455.m
------------------------------------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Rocket-Plane Mission-1, Descent Phase (Pitch Design Model)
System
pitch_455_LQR
------------------------------------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Rocket-Plane Mission-1, Descent Phase (Lateral Design Model)
System
later_455_LQR
------------------------------------------------------------------------------------------------------------------------------------------------------------
END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-
